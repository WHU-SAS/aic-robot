# Keil uVision project uart1_link.uvprojx, settings and files
target Tianmengxing_UART1_Link_Test (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(32000000) ELITTLE
  output: uart1_link +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c include: ..;..\..\01_motor_encoder\source;..\..\01_motor_encoder\source\third_party\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: ..\..\01_motor_encoder\keil\mspm0g3507.sct
  link misc: ../../01_motor_encoder/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group UART1 Link Test
    ../: main.c
    ../../01_motor_encoder/keil/: startup_mspm0g350x_uvision.s
